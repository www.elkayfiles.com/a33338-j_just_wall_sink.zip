Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2023-11-14T20:09:53
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.1.109 - Exporter 21.1.1.109 - Alternate UI 21.1.1.109
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Nov 14 20:09:53 2023 * Host: ZILFY3SGS3 * Database: C:\Users\ENIDAM~1\AppData\Local\Temp\750a4638-45c4-46ed-b2f3-5668f2f2efc4\9b05a4a8-1954-4ecd-8eef-1feb65bc747a\ifc * Database version: 5507 * Database creation date: Tue Nov 14 20:09:53 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Nov 14 20:09:53 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Nov 14 20:09:53 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 ft
Pset_ProductRequirements - Category: Project Information

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Pset_ProductRequirements - Category: Project Information

# IfcBuildingStorey: Level:1/4" Head, Level 1
LongName: Level 1; Elevation: 0 ft
Pset_AirSideSystemInformation - Name: Level 1
Pset_ProductRequirements - Name: Level 1; Category: Levels

# IfcFlowTerminal: A33338-J:A33338-J, A33338-J:A33338-J:811942
In: Level 1
Type - Material: Metal - Steel - Stainless - Chrome
Type - Pset_ManufacturerTypeInformation - Manufacturer: www.justmfg.com
Type - Pset_ProductRequirements - Category: Plumbing Fixtures
Type - Pset_QuantityTakeOff - Reference: A33338-J
Pset_DistributionFlowElementCommon - Reference: A33338-J; sets with these values: 2
